# Keil uVision project stm32_nonos_simple.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_nonos_simple
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FreeRTOS\Source\include;..\FreeRTOS;..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../system/: main.c key.c led.c uart.c fnd.c cds.c freertos_test.c
  group freertos_kernel
    ../FreeRTOS/Source/: list.c queue.c tasks.c
  group freertos_ports
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
